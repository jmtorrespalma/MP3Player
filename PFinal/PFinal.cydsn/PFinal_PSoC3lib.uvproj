# Keil uVision project PFinal_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: PFinal_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h WaveDAC8.c WaveDAC8.h WaveDAC8_PM.c Pin_Senal.c Pin_Senal.h Pin_Senal_aliases.h WaveDAC8_DacClk.c WaveDAC8_DacClk.h WaveDAC8_Wave1_DMA_dma.c WaveDAC8_Wave1_DMA_dma.h WaveDAC8_Wave2_DMA_dma.c WaveDAC8_Wave2_DMA_dma.h WaveDAC8_VDAC8.c WaveDAC8_VDAC8.h WaveDAC8_VDAC8_PM.c CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h Pin_400.c Pin_400.h Pin_400_aliases.h Pin_500.c Pin_500.h Pin_500_aliases.h Pin_600.c Pin_600.h Pin_600_aliases.h Pin_700.c Pin_700.h Pin_700_aliases.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: PFinal_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
